Commit message: update for new hand

File: assets/urdf/ycb_pybullet/plastic_apple/model.urdf (robot description, URDF)
Before this commit: robot model.urdf, 1 links, 0 joints
Links:
- link baseLink: mass 0.1 -> 0.067
